# IAR project OpenOSEK.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM3S4 Atmel AT91SAM3S4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\..\OpenAPP\inc; ..\..\..\OpenAPP\out; ..\..\..\OpenRTOS\inc; ..\..\..\OpenRTOS\src; ..\..\..\OpenRTOS\src\portable\at91sam3s; ..\..\..\OpenDriver\inc; ..\..\..\OpenCom\inc; ..\..\..\OpenCom\config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Makefile.srec
  ILINK.IlinkOutputFile: Makefile.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group OpenApp/config
    ../../config/: OpenAPP.oil
  group OpenApp/out
    ../../out/: comcfg.c comcfg.h oscfg.c oscfg.h
  group OpenApp/src
    ../../src/: app.c
  group OpenApp/src/start
    ../../src/start/: main.c
  group OpenCom/config
    ../../../OpenCom/config/: Dll_Cfg.c NM_Cfg.c OpenCom.oil Uds_Cfg.c Uds_Cfg.h
  group OpenCom/inc
    ../../../OpenCom/inc/: CanTp.h Com.h ComStack_Types.h Dll.h Nm.h Uds.h
  group OpenCom/src
    ../../../OpenCom/src/: CanTp.c Dll.c Nm.c Uds.c
  group OpenDriver/inc
    ../../../OpenDriver/inc/: Can.h
  group OpenDriver/src
    ../../../OpenDriver/src/at91sam3s/: Can.c
  group OpenRTOS/inc
    ../../../OpenRTOS/inc/: Debug.h Os.h Std_Types.h
  group OpenRTOS/src
    ../../../OpenRTOS/src/: alarm.c event.c interrupt.c osctrl.c osek_os.h resource.c task.c
  group OpenRTOS/src/portable/at91sam3s
    ../../../OpenRTOS/src/portable/at91sam3s/: portable.c portable.h
  group OpenRTOS/src/portable/at91sam3s/icc
    ../../../OpenRTOS/src/portable/at91sam3s/icc/: portableS.S startup.S
