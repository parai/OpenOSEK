# IAR project OpenOSEK.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F107xC ST STM32F107xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_CL; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\OpenAPP\inc; ..\..\..\OpenAPP\out; ..\..\..\OpenRTOS\inc; ..\..\..\OpenRTOS\src; ..\..\..\OpenRTOS\src\portable\stm32f107vc; ..\..\..\OpenDriver\inc; ..\..\..\OpenDriver\src\stm32f107vc; ..\..\..\OpenCom\inc; ..\..\..\OpenCom\config; ..\..\..\OpenLib\stm32f1\libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\OpenLib\stm32f1\libraries\STM32_USB-OTG-FS_Driver\inc; ..\..\..\OpenLib\stm32f1\libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: OpenOSEK.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group OpenAPP/config
    ../../config/: OpenAPP.oil
  group OpenAPP/out
    ../../out/: comcfg.c comcfg.h oscfg.c oscfg.h
  group OpenAPP/src
    ../../src/: app.c
  group OpenAPP/src/start
    ../../src/start/: main.c
  group OpenCom/config
    ../../../OpenCom/config/: Dll_Cfg.c NM_Cfg.c OpenCom.oil Uds_Cfg.c Uds_Cfg.h
  group OpenCom/inc
    ../../../OpenCom/inc/: CanTp.h Com.h ComStack_Types.h Dll.h Nm.h Uds.h
  group OpenCom/src
    ../../../OpenCom/src/: CanTp.c Dll.c Nm.c Uds.c
  group OpenDriver/inc
    ../../../OpenDriver/inc/: Can.h
  group OpenDriver/src
    ../../../OpenDriver/src/stm32f107vc/: Can.c
  group OpenLib/stm32f1/libraries/CMIS/CM3/DeviceSupport/ST
    ../../../OpenLib/stm32f1/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group OpenLib/stm32f1/libraries/STM32_USB-OTG-FS_Driver/inc
    ../../../OpenLib/stm32f1/libraries/STM32_USB-OTG-FS_Driver/inc/: usb_conf.h usb_core.h usb_defines.h usb_hcd.h usb_otg.h usb_pcd.h usb_regs.h
  group OpenLib/stm32f1/libraries/STM32_USB-OTG-FS_Driver/src
    ../../../OpenLib/stm32f1/libraries/STM32_USB-OTG-FS_Driver/src/: usb_core.c usb_hcd.c usb_otg.c usb_pcd.c
  group OpenLib/stm32f1/libraries/STM32F10x_StdPeriph_Driver/inc
    ../../../OpenLib/stm32f1/libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_conf.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group OpenLib/stm32f1/libraries/STM32F10x_StdPeriph_Driver/src
    ../../../OpenLib/stm32f1/libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group OpenRTOS/inc
    ../../../OpenRTOS/inc/: Debug.h Os.h Std_Types.h
  group OpenRTOS/src
    ../../../OpenRTOS/src/: alarm.c event.c interrupt.c osctrl.c osek_os.h resource.c task.c
  group OpenRTOS/src/portable/stm32f107vc
    ../../../OpenRTOS/src/portable/stm32f107vc/: portable.c portable.h
  group OpenRTOS/src/portable/stm32f107vc/icc
    ../../../OpenRTOS/src/portable/stm32f107vc/icc/: portableS.S startup.S
